Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Simili potelet amovible.IFC
Time: 2020-07-02T06:21:06
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: SIMI-POT-AM-003_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 10.4703; Area Measure: 0.848587; Volume Measure: 0.00153046

# IfcBuildingElementProxy: SIMI-POT-MUL-001_Default
In: Default Storey
Material: 6060

# IfcBuildingElementProxy: SIMI-POT-MUL-002_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: VEST-POT-100-AM-002_Default
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: VEST-POT-MUL-001_Default
In: Default Storey
Material: S 235
