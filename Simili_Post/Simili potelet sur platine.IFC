Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Simili potelet sur platine.IFC
Time: 2020-07-02T06:21:51
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: SIMI-POT-AM-003_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: SIMI-POT-MUL-001_Default
In: Default Storey
Material: 6060
PSet_Mass_Property - Mass Measure: 6.51386; Area Measure: 0.574648; Volume Measure: 0.0010252

# IfcBuildingElementProxy: SIMI-POT-MUL-003_Default
In: Default Storey
Material: S 235
